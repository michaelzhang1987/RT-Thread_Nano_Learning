<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RTT_Nano_STM32F103RCT6_CUBEMX.ewp</path>
  </project>
  <batchBuild />
</workspace>
