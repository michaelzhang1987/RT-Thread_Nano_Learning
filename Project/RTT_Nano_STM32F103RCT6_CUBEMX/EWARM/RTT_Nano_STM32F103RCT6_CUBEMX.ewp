# IAR project RTT_Nano_STM32F103RCT6_CUBEMX.ewp, settings and files
configuration RTT_Nano_STM32F103RCT6_CUBEMX (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/components/finsh/; ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/include/; ../CODE
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTT_Nano_STM32F103RCT6_CUBEMX.hex
  ILINK.IlinkOutputFile: RTT_Nano_STM32F103RCT6_CUBEMX.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../CODE/: RTT_Target_InPut.c RTT_Target_InPut.h
  group Application/CODE
    ../CODE/: EEROM_STM32_Flash.c EEROM_STM32_Flash.h General_Definition_MGQ.h General_Uart.c General_Uart.h RTT_Can_Drv.c RTT_Can_Drv.h RTT_Nano_Include.h RTT_Target_Group_Ctrl.c RTT_Target_Group_Ctrl.h RTT_Target_OutPut.c RTT_Target_OutPut.h RTT_Target_System_State.c RTT_Target_System_State.h RTT_Uart_Console_IT.c RTT_Uart_Console_IT.h
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c can.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/RT-Thread
    ../Inc/: rtconfig.h
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/include/: rtthread.h
  group Middlewares/RT-Thread/RTOS/shell
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/components/finsh/: shell.c cmd.c msh.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/bsp/: board.c
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
